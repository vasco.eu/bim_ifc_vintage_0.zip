Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2018-11-19T10:58:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.0.1185.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 19 10:58:42 2018 * Host: ZZ020160 * Database: C:\Users\BRITTP~1\AppData\Local\Temp\{4931923F-2513-4C8E-B275-FEFC443800B8}\ifc * Database version: 5507 * Database creation date: Mon Nov 19 10:58:41 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 19 10:58:42 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 19 10:58:42 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -35, -18, -23, -549194; RefLongitude: 149, 7, 35, 603027; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Ground Floor; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - Triangle (AUS): Type 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Ventielset - Sluitnippel (4)
In: Ground Floor
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Ventielset - Sluitnippel
Type - Other - Category: Mechanical Equipment; Family Name: Ventielset - Sluitnippel
Pset_BuildingElementProxyCommon - Reference: Ventielset - Sluitnippel
Constraints - Host: Level : Ground Floor; Level: Level: Ground Floor; Moves With Nearby Elements: no
Dimensions - Area: 0.00148457 m2; Volume: 0.0000116913 m3
Other - Family: Ventielset - Sluitnippel: Ventielset - Sluitnippel; Family and Type: Ventielset - Sluitnippel: Ventielset - Sluitnippel; Type: Ventielset - Sluitnippel: Ventielset - Sluitnippel; Type Id: Ventielset - Sluitnippel: Ventielset - Sluitnippel
Phasing - Phase Created: New Construction
Name (Ventielset - Sluitnippel:Ventielset - Sluitnippel:...) | Offset (mm) | Mark
207705 | 190 | 2
207706 | 710 | 3
207707 | 190 | 4
207708 | 710 | 5

# IfcBuildingElementProxy: Vintage_378_600, Vintage 160:Vintage_378_600:207704
In: Ground Floor
Type - Material: White Fine Texture
Type - Dimensions - distance: 24 mm; épaisseur: 160 mm; épaisseur_01: 140 mm; hauteur: 600 mm; hauteur_01: 580 mm; largeur: 378 mm
Type - Energy Analysis - émission_chauffage: 5500.36
Type - General - débit_r01: 0 m3/s; débit_r02: 0 m3/s; diamètre_r01: 30 mm; diamètre_r02: 30 mm
Type - Identity Data - Description: Vintage 50/160; Manufacturer: Vasco; Model: Vintage; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: Vintage_378_600; URL: https://superia.be/be-nl/radiatoren/ledenradiator-lr
Type - Materials and Finishes - clause de non-responsabilité: Les couleurs peuvent diverger des couleurs affichées à l'écran. Pour les couleurs exactes, veuillez utiliser le nuancier de Vasco.; couleur RAL/RVB: 9016; matière: White Fine Texture; Nom de couleur: White Fine Texture; non disponible: Sans objet
Type - Mechanical - puissance: 5500.36; rac 1_angle hor: 0 deg; rac 1_angle ver: 0 deg; rac 1_pos x: 129 mm; rac 1_pos y: 80 mm; rac 1_pos z: 190 mm; rac 2_angle hor: 0 deg; rac 2_angle ver: 0 deg; rac 2_pos x: 129 mm; rac 2_pos y: 80 mm; rac 2_pos z: 190 mm
Type - Mechanical - Flow - delta_T: 10; facteur_delta_T: 50; température_ambiance: 20 kg/K/s3; température de départ: 75 kg/K/s3; température de retour: 65 kg/K/s3
Type - Other - Category: Mechanical Equipment; code_ETIM: EC011023; code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC011023&classVersion=4; Family Name: Vintage 160; nombre: 8
Type - Text - Poids: 14
Pset_BuildingElementProxyCommon - Reference: Vintage_378_600
Pset_ManufacturerTypeInformation - Manufacturer: Vasco
Constraints - Host: Level : Ground Floor; Level: Level: Ground Floor; Offset: 0 mm
Dimensions - Area: 0.38328 m2; Volume: 0.036288 m3
Identity Data - Mark: 1
Mechanical - System Classification: Hydronic Supply,Hydronic Return
Other - Family: Vintage 160: Vintage_378_600; Family and Type: Vintage 160: Vintage_378_600; Type: Vintage 160: Vintage_378_600; Type Id: Vintage 160: Vintage_378_600
Phasing - Phase Created: New Construction
